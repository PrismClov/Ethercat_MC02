# Keil uVision project EcatDemoMC02.uvprojx, settings and files
target EcatDemoMC02 (6180000::V6.18::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2401FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: EcatDemoMC02 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32H723xx,LAN9252
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/DSP_math/Core/Inc;../Middlewares/DSP_math/DSP/Inc/dsp;../Middlewares/DSP_math/DSP/Inc;../Middlewares/DSP_math/DSP/PrivateInclude;../Middlewares/SEGGER_RTT/Config;../Middlewares/SEGGER_RTT/RTT;../User/Bsp/Inc;../User/Devices/Inc;../User/EtherCAT;../User/Start/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x20000
  group Bsp
    ../User/Bsp/Src/: bsp_adc.c bsp_can.c bsp_dwt.c bsp_gpio.c bsp_mcu.c bsp_pwm.c bsp_spi.c bsp_tick.c bsp_uart.c bsp_tim.c
    ../User/Bsp/Inc/: bsp_adc.h bsp_can.h bsp_dwt.h bsp_gpio.h bsp_mcu.h bsp_pwm.h bsp_spi.h bsp_tick.h bsp_uart.h bsp_tim.h
  group Devices
    ../User/Devices/Src/: ws2812.c Bmi088.c Vofa.c
    ../User/Devices/Inc/: ws2812.h Bmi088.h Bmi088_Reg.h Vofa.h
  group EtherCAT
    ../User/EtherCAT/: 9252_HW.c 9252_HW.h applInterface.h coeappl.c coeappl.h ecat_def.h ecatappl.c ecatappl.h ecatcoe.c ecatcoe.h ecateoe.c ecateoe.h ecatfoe.c ecatfoe.h ecatslv.c ecatslv.h emcy.c emcy.h eoeappl.c eoeappl.h esc.h foeappl.c foeappl.h GenericTypeDefs.h mailbox.c mailbox.h objdef.c objdef.h sdoserv.c sdoserv.h SPIDriver.c SPIDriver.h SSC_Device.c SSC_Device.h SSC_DeviceObjects.h
  group Start
    ../User/Start/Src/: ALL_Init.c WHW_IRQN.c
    ../User/Start/Inc/: ALL_Init.h WHW_IRQN.h
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c bdma.c dma.c fdcan.c memorymap.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group SEGGER
    ../Middlewares/SEGGER_RTT/Config/: SEGGER_RTT_Conf.h
    ../Middlewares/SEGGER_RTT/RTT/: SEGGER_RTT.c SEGGER_RTT.h SEGGER_RTT_ASM_ARMv7M.S SEGGER_RTT_printf.c
  group DSPmath
    ../Middlewares/DSP_math/DSP/Src/BasicMathFunctions/: BasicMathFunctions.c
    ../Middlewares/DSP_math/DSP/Src/BayesFunctions/: BayesFunctions.c
    ../Middlewares/DSP_math/DSP/Src/CommonTables/: CommonTables.c
    ../Middlewares/DSP_math/DSP/Src/ComplexMathFunctions/: ComplexMathFunctions.c
    ../Middlewares/DSP_math/DSP/Src/ControllerFunctions/: ControllerFunctions.c
    ../Middlewares/DSP_math/DSP/Src/DistanceFunctions/: DistanceFunctions.c
    ../Middlewares/DSP_math/DSP/Src/FastMathFunctions/: FastMathFunctions.c
    ../Middlewares/DSP_math/DSP/Src/FilteringFunctions/: FilteringFunctions.c
    ../Middlewares/DSP_math/DSP/Src/InterpolationFunctions/: InterpolationFunctions.c
    ../Middlewares/DSP_math/DSP/Src/MatrixFunctions/: MatrixFunctions.c
    ../Middlewares/DSP_math/DSP/Src/QuaternionMathFunctions/: QuaternionMathFunctions.c
    ../Middlewares/DSP_math/DSP/Src/StatisticsFunctions/: StatisticsFunctions.c
    ../Middlewares/DSP_math/DSP/Src/SupportFunctions/: SupportFunctions.c
    ../Middlewares/DSP_math/DSP/Src/SVMFunctions/: SVMFunctions.c
    ../Middlewares/DSP_math/DSP/Src/TransformFunctions/: TransformFunctions.c
    ../Middlewares/DSP_math/DSP/Src/WindowFunctions/: WindowFunctions.c
